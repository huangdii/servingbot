Commit message: zed camera Particle OK

File: urdf/zed.urdf (robot description, URDF)
Before this commit: robot zed_camera, 6 links, 5 joints
Joints:
- joint zed_camera_center_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0.0 0.0 0 rpy=0 0 0
